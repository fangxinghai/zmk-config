## modules/ble_toggle/Kconfig
```kconfig
config CUSTOM_BLE_TOGGLE
    bool "Custom encoder debounce + volume slider"
    default y
    depends on BT
    depends on ADC
```
